options:
  parameters:
    generate_options: no_gui
    id: decsink
    output_language: python
    run_options: run
    title: 317 IQ Pre-processing
  states: {}

blocks:
- name: dec
  id: variable
  parameters:
    value: '16'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '50000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: sink_name
    type: complex
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: source_name
    offset: startind
    repeat: 'False'
    type: complex
  states: {}
- name: filter_fft_low_pass_filter_0
  id: filter_fft_low_pass_filter
  parameters:
    cutoff_freq: samp_rate/(dec*2)
    decim: dec
    gain: '1'
    samp_rate: samp_rate
    type: ccc
    width: samp_rate/(dec*2*16)
    win: window.WIN_HANN
  states: {}
- name: sink_name
  id: parameter
  parameters:
    label: default_processed.bin
    type: str
    value: '0'
  states: {}
- name: source_name
  id: parameter
  parameters:
    label: default.bin
    type: str
    value: '0'
  states: {}
- name: startind
  id: parameter
  parameters:
    type: intx
    value: '0'
  states: {}

connections:
- [blocks_file_source_0_0, '0', filter_fft_low_pass_filter_0, '0']
- [filter_fft_low_pass_filter_0, '0', blocks_file_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
